# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\source;..\MyDriver;..\..\project;..\MyDriver\Control;..\MyDriver\IMU;..\MyDriver\IMU\ICM45686;..\MyDriver\Motor;..\MyDriver\UART;..\MyDriver\Soft Drive;..\MyDriver\OLED;..\MyDriver\Servo;..\MyDriver\Track;..\MyDriver\Gray;..\MyDriver\ADC;..\MyDriver\Question;..\MyDriver\Key;..\zf_common;..\zf_device;..\zf_drive;..\MyDriver\Peripheral
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c
    ./: startup_mspm0g350x_uvision.s
  group DriverLib
    ../ti/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
  group MyDriver
    ../MyDriver/Control/: Control.c
    ../MyDriver/IMU/: quaternion.c
    ../MyDriver/Motor/: Encoder.c Motor.c
    ../MyDriver/Soft Drive/: MySPI.c
    ../MyDriver/UART/: UART.c
    ../MyDriver/OLED/: OLED.c OLED_Data.c
    ../MyDriver/Track/: track.c
    ../MyDriver/ADC/: ADC.c
    ../MyDriver/Gray/: No_Mcu_Ganv_Grayscale_Sensor.c
    ../MyDriver/Question/: Question.c
    ../MyDriver/Key/: key.c
    ../MyDriver/Peripheral/: peripheral.c
  group ICM45686
    ../MyDriver/IMU/ICM45686/: basic_read_reg.c inv_imu_driver.c inv_imu_transport.c
  group zf_common
    ../zf_common/: zf_common_debug.c zf_common_debug.h zf_common_function.c zf_common_function.h zf_common_typedef.h
  group zf_device
    ../zf_device/: zf_device_config.h zf_device_config.lib zf_device_dl1b.c zf_device_dl1b.h zf_device_type.c zf_device_type.h
  group zf_drive
    ../zf_drive/: zf_driver_gpio.c zf_driver_gpio.h zf_driver_soft_iic.c zf_driver_soft_iic.h
